# Keil uVision project GPIO.uvprojx, settings and files
target GPIO (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GPIO +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX
  c misc: --cpp11
  c include: .\inc;..\STM32F4xx_StdPeriph_Driver;..\STM32F4xx_StdPeriph_Driver\inc;.\RTE\Device\STM32F407VGTx;.\lib
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MainSource
    ./src/: delay.c main.c encoder.c motor_driver_TB6612FNG.c pwm_test.c
    ./lib/: tm_stm32f4_gpio.c tm_stm32f4_i2c.c tm_stm32f4_mpu6050.c tm_stm32f4_rcc.c
  group include
    ./inc/: delay.h encoder.h motor_driver_TB6612FNG.h pwm_test.h
    ./lib/: attributes.h defines.h tm_stm32f4_gpio.h tm_stm32f4_i2c.h tm_stm32f4_mpu6050.h tm_stm32f4_rcc.h
  group STM32F4xx_StdPeriph_Driver
    ../STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_i2c.c
software components: CMSIS:CORE 5.0.0, Device:Startup 2.5.0
